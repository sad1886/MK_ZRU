# Keil uVision project ZRU.uvprojx, settings and files
target PSD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZRU +hex
  c flags: Optim=1
  c misc: --fp16_format=ieee
  c include: .\cmsis;.\src;.\lcd
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./arm/: startup_MDR32F9Qx.s
  group cmsis
    ./cmsis/: core_cm3.c MDR32F9Qx_iwdg.c
    ./arm/: system_MDR32F9Qx.c
  group src
    ./src/: main.c init.c Work.c Can.c init_IWDG.c IrqHandlers.c Uart.c
software components: CMSIS:CORE 4.3.0
